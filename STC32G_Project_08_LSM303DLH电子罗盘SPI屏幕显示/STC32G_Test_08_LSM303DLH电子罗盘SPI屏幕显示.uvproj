# Keil uVision project STC32G_Test_08_LSM303DLH电子罗盘SPI屏幕显示.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_Test_08_LSM303DLH电子罗盘SPI屏幕显示 +hex
  group Source Group 1
    ./: main.c
    ./Internals/: spi.c iic.c
    ./Externals/: lsm303.c oled.c
