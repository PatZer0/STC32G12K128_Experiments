# Keil uVision project STC32G_Test_04_I2C通信OLED屏.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G128K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x80000-0x9FFFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_Test_04_I2C通信OLED屏 +hex
  group Source Group 1
    ./: main.c iic.c oled.c
